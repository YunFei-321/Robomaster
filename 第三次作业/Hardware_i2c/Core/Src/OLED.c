#include "OLED.h"
#include <stdio.h>
#include <string.h>

/* ==========================================
 * OLED SSD1306 Graphic Definitions
 * ========================================== */
#define OLED_WIDTH 128
#define OLED_HEIGHT 64
#define OLED_PAGES 8
static uint8_t oled_buffer[OLED_WIDTH * OLED_PAGES];
static I2C_HandleTypeDef *p_hi2c;

/* ASCII 5x7 Font Table */
static const uint8_t OLED_FONT[95][5] = {//字符库
    {0x00,0x00,0x00,0x00,0x00}, {0x00,0x00,0x5F,0x00,0x00}, {0x00,0x07,0x00,0x07,0x00},
    {0x14,0x7F,0x14,0x7F,0x14}, {0x24,0x2A,0x7F,0x2A,0x12}, {0x23,0x13,0x08,0x64,0x62},
    {0x36,0x49,0x55,0x22,0x50}, {0x00,0x05,0x03,0x00,000}, {0x00,0x1C,0x22,0x41,0x00},
    {0x00,0x41,0x22,0x1C,0x00}, {0x14,0x08,0x3E,0x08,0x14}, {0x08,0x08,0x3E,0x08,0x08},
    {0x00,0x50,0x30,0x00,0x00}, {0x08,0x08,0x08,0x08,0x08}, {0x00,0x60,0x60,0x00,0x00},
    {0x20,0x10,0x08,0x04,0x02}, {0x3E,0x51,0x49,0x45,0x3E}, {0x00,0x42,0x7F,0x40,0x00},
    {0x42,0x61,0x51,0x49,0x46}, {0x21,0x41,0x45,0x4B,0x31}, {0x18,0x14,0x12,0x7F,0x10},
    {0x27,0x45,0x45,0x45,0x39}, {0x3C,0x4A,0x49,0x49,0x30}, {0x01,0x71,0x09,0x05,0x03},
    {0x36,0x49,0x49,0x49,0x36}, {0x06,0x49,0x49,0x29,0x1E}, {0x00,0x36,0x36,0x00,0x00},
    {0x00,0x56,0x36,0x00,0x00}, {0x08,0x14,0x22,0x41,0x00}, {0x14,0x14,0x14,0x14,0x14},
    {0x00,0x41,0x22,0x14,0x08}, {0x02,0x01,0x51,0x09,0x06}, {0x32,0x49,0x59,0x51,0x3E},
    {0x7C,0x12,0x11,0x12,0x7C}, {0x7F,0x49,0x49,0x49,0x36}, {0x3E,0x41,0x41,0x41,0x22},
    {0x7F,0x41,0x41,0x22,0x1C}, {0x7F,0x49,0x49,0x49,0x41}, {0x7F,0x09,0x09,0x09,0x01},
    {0x3E,0x41,0x49,0x49,0x7A}, {0x7F,0x08,0x08,0x08,0x7F}, {0x00,0x41,0x7F,0x41,0x00},
    {0x20,0x40,0x41,0x3F,0x01}, {0x7F,0x08,0x14,0x22,0x41}, {0x7F,0x40,0x40,0x40,0x40},
    {0x7F,0x02,0x0C,0x02,0x7F}, {0x7F,0x04,0x08,0x10,0x7F}, {0x3E,0x41,0x41,0x41,0x3E},
    {0x7F,0x09,0x09,0x09,0x06}, {0x3E,0x41,0x51,0x21,0x5E}, {0x7F,0x09,0x19,0x29,0x46},
    {0x46,0x49,0x49,0x49,0x31}, {0x01,0x01,0x7F,0x01,0x01}, {0x3F,0x40,0x40,0x40,0x3F},
    {0x1F,0x20,0x40,0x20,0x1F}, {0x3F,0x40,0x38,0x40,0x3F}, {0x63,0x14,0x08,0x14,0x63},
    {0x07,0x08,0x70,0x08,0x07}, {0x61,0x51,0x49,0x45,0x43}, {0x00,0x7F,0x41,0x41,0x00},
    {0x02,0x04,0x08,0x10,0x20}, {0x00,0x41,0x41,0x7F,0x00}, {0x04,0x02,0x01,0x02,0x04},
    {0x40,0x40,0x40,0x40,0x40}, {0x00,0x01,0x02,0x04,0x00}, {0x20,0x54,0x54,0x54,0x78},
    {0x7F,0x48,0x44,0x44,0x38}, {0x38,0x44,0x44,0x44,0x20}, {0x38,0x44,0x44,0x48,0x7F},
    {0x38,0x54,0x54,0x54,0x18}, {0x08,0x7E,0x09,0x01,0x02}, {0x0C,0x52,0x52,0x52,0x3E},
    {0x7F,0x08,0x04,0x04,0x78}, {0x00,0x44,0x7D,0x40,0x00}, {0x20,0x40,0x44,0x3D,0x00},
    {0x7F,0x10,0x28,0x44,0x00}, {0x00,0x41,0x7F,0x40,0x00}, {0x7C,0x04,0x18,0x04,0x78},
    {0x7C,0x08,0x04,0x04,0x78}, {0x38,0x44,0x44,0x44,0x38}, {0x7C,0x14,0x14,0x14,0x08},
    {0x08,0x14,0x14,0x18,0x7C}, {0x7C,0x08,0x04,0x04,0x08}, {0x48,0x54,0x54,0x54,0x20},
    {0x04,0x3F,0x44,0x40,0x20}, {0x3C,0x40,0x40,0x20,0x7C}, {0x1C,0x20,0x40,0x20,0x1C},
    {0x3C,0x40,0x30,0x40,0x3C}, {0x44,0x28,0x10,0x28,0x44}, {0x0C,0x50,0x50,0x50,0x3C},
    {0x44,0x64,0x54,0x4C,0x44}, {0x00,0x08,0x36,0x41,0x00}, {0x00,0x00,0x7F,0x00,0x00},
    {0x00,0x41,0x36,0x08,0x00}, {0x10,0x08,0x08,0x10,0x08}
};

/* ==========================================
 * HAL Hardware I2C Operations
 * ========================================== */
static void OLED_Write_Cmd(uint8_t cmd) {// 命令
    uint8_t data[] = {0x00, cmd};
    HAL_I2C_Master_Transmit(p_hi2c, OLED_I2C_ADDR, data, 2, HAL_MAX_DELAY);
}

static void OLED_Write_Data(uint8_t *data, uint16_t len) {//数据发送
    uint8_t header = 0x40;
    HAL_I2C_Mem_Write(p_hi2c, OLED_I2C_ADDR, header, 1, data, len, HAL_MAX_DELAY);
}

/* ==========================================
 * Graphic Functions
 * ========================================== */
static void OLED_Draw_Char(uint8_t x, uint8_t y, char c) {//将字符写入缓存区
    if (x > OLED_WIDTH - 6 || y >= OLED_PAGES || c < ' ' || c > '~') return;
    uint8_t idx = c - ' ';
    for (uint8_t col = 0; col < 5; col++) {
        oled_buffer[y * OLED_WIDTH + x + col] = OLED_FONT[idx][col];
    }
}

static void OLED_Draw_String(uint8_t x, uint8_t y, char *str) {//连续写入读取字符
    while (*str && x < OLED_WIDTH - 6) {
        OLED_Draw_Char(x, y, *str++);
        x += 6;
    }
}

void OLED_Init(I2C_HandleTypeDef *hi2c) {//初始化
    p_hi2c = hi2c;

    uint8_t cmds[] = {0xAE, 0xD5, 0x80, 0xA8, 0x3F, 0xD3, 0x00, 0x40, 0x8D, 0x14,
                      0x20, 0x00, 0xA1, 0xC8, 0xDA, 0x12, 0x81, 0xCF, 0xA4, 0xA6, 0xAF};
    for(int i=0; i<sizeof(cmds); i++) OLED_Write_Cmd(cmds[i]);

    memset(oled_buffer, 0, sizeof(oled_buffer));
}

static void OLED_Update_Display(void) {//将缓存的数据一次性读写到屏幕上
    for (uint8_t page = 0; page < OLED_PAGES; page++) {
        OLED_Write_Cmd(0xB0 | page);
        OLED_Write_Cmd(0x00); OLED_Write_Cmd(0x10);
        OLED_Write_Data(&oled_buffer[page * OLED_WIDTH], OLED_WIDTH);
    }
}

/* ==========================================
 * Status Display Logic (Matches Image)
 * ========================================== */
void OLED_Show_Status(void) {//显示状态字符
    char buf[16];
    memset(oled_buffer, 0, sizeof(oled_buffer));

    OLED_Draw_String(0, 0, "STATE: ");
    OLED_Draw_String(42, 0, g_is_running ? "RUN" : "STOP");

    OLED_Draw_String(0, 1, "DIR: ");
    OLED_Draw_String(30, 1, g_direction == 0 ? "FWD" : "REV");

    OLED_Draw_String(0, 2, "STEP: ");
    sprintf(buf, "%dms", g_step_ms);
    OLED_Draw_String(36, 2, buf);

    OLED_Draw_String(0, 3, "LED: ");
    sprintf(buf, "%d", g_current_led_idx + 1);
    OLED_Draw_String(30, 3, buf);

    OLED_Update_Display();
}